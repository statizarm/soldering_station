# Keil uVision project soldering_station.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: soldering_station
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: application.c application.h font.c font.h frame.c frame.h global.c global.h ili9341_driver.c ili9341_driver.h init.c main.c regulator.c regulator.h Roboto Mono Medium24.c Roboto Mono Medium64.c sem.c sem.h semc.c task.c task.h temperature.c temperature.h ui.c ui.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0

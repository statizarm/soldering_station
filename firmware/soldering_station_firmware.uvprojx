# Keil uVision project soldering_station_firmware.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: soldering_station_firmware
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c init.c ili9341_driver.c ili9341_driver.h task.h task.c ui.h sem.c sem.h global.c frame.h frame.c ui.c global.h temperature.c temperature.h regulator.c regulator.h application.c application.h font.c font.h Roboto Mono Medium24.c Roboto Mono Medium64.c semc.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
